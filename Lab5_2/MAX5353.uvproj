# Keil uVision project MAX5353.uvproj, settings and files
target MAX5353 (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: MAX5353
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --c99
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s SysTick.c PLL.h PLL.c tm4c123gh6pm.h Switch.c Switch.h Music.c Music.h Timer0A.h Timer0A.c SysTick.h DAC.h DAC.c main.c
