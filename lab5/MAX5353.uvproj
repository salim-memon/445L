# Keil uVision project MAX5353.uvproj, settings and files
target MAX5353 (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: MAX5353
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --c99
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s MAX5353.c MAX5353TestMain.c SysTick.c Timer0A.c Timer0A.h tm4c123gh6pm.h SysTick.h Switch.h Switch.c DAC.c Music.c PLL.c PLL.h Player.c
