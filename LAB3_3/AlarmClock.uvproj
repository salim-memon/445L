# Keil uVision project AlarmClock.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: AlarmClock
  c flags: Optim=1
  group Source Group 1
    ./: PLL.c PLL.h ST7735.c ST7735.h Switch.c Switch.h SysTick.c SysTick.h Timer1.c Timer1.h speaker.c speaker.h AlarmClockMain.c AlarmClockMain.h lcd.c LCD.h startup.s
