# Keil uVision project alarmclockmain.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: alarmclockmain
  c flags: Optim=1
  group Source Group 1
    ./: PLL.c PLL.h speaker.c speaker.h ST7735.c ST7735.h Switch.c Switch.h SysTick.c SysTick.h tm4c123gh6pm.h main.c Timer0A.h Timer0A.c startup.s PWM.c PWM.h LCDscreen.c LCDscreen.h
